# Keil uVision project GD32KeilPrj.uvprojx, settings and files
target Target 1 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: GD32F303ZE GigaDevice
  pack: GigaDevice.GD32F30x_DFP.2.1.0
  cpu: IRAM(0x20000000,0x010000) IROM(0x08000000,0x080000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: GD32KeilPrj +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: USE_STDPERIPH_DRIVER,GD32F30X_HD
  c include: ..\FW\Include;..\App\Main;..\App\LED;..\App\KeyOne;..\App\Delay;..\ARM\System;..\ARM\NVIC;..\HW\RCU;..\HW\Timer;..\HW\UART0;..\App\DataType;..\OS
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group App
    ../App/Main/: Main.c
    ../App/LED/: LED.c
    ../App/KeyOne/: KeyOne.c
    ../App/Delay/: Delay.c
  group HW
    ../HW/RCU/: RCU.c
    ../HW/Timer/: Timer.c
    ../HW/UART0/: CirQueue.c UART0.c
  group OS
    ../OS/: CasyOS.c os_flag.c os_mem.c os_mutex.c os_q.c os_sem.c os_task.c
  group FW
    ../FW/Source/: gd32f30x_fmc.c gd32f30x_gpio.c gd32f30x_misc.c gd32f30x_rcu.c gd32f30x_timer.c gd32f30x_usart.c gd32f30x_dma.c
  group ARM
    ../ARM/System/: gd32f30x_it.c system_gd32f30x.c startup_gd32f30x_hd.s
    ../ARM/NVIC/: NVIC.c
software components: CMSIS:CORE 5.4.0
